PACKAGECONFIG:append = " v4l dnn"
PACKAGECONFIG:remove = " gtk qt5"
